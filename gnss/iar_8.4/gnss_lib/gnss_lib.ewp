# IAR project gnss_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M7 Cypress CYT4BF_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh8m; char_t=char; float32_t=float; float64_t=double; CYT4BFBCHS; CY_USE_PSVP=0; CY_MCU_rev_b; CPU_BOARD_REVA; CY_CORE_CM7_1; BT_ENABLE=1; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtk_ins.srec
  ILINK.IlinkOutputFile: ins.hex
  ILINK.IlinkConfigDefines: _CORE_cm7_1_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\..\..\linker\linker_directives_tviibh.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include
    ../../include/: ephemeris.h gnss_datatype.h gnss_filter.h gnssapp.h gpsAPI.h gpsconfig.h lambda.h model.h print_nmea.h pvt_eng.h RingBuffer.h rtcm.h rtk_eng.h rtk_math.h rtkcmn.h rtklib_core.h
  group interface
    ../../: taskRTK.h
  group src
    ../../src/: ephemeris.c gnss_filter.c lambda.c model.c print_nmea.c RingBuffer.c rtcm.c rtk_eng.c rtk_math.c rtkcmn.c pvt_eng.c gnss_integrity.c
