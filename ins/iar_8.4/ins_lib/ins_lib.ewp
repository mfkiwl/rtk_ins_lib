# IAR project ins_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M7 Cypress CYT4BF_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh8m; char_t=char; float32_t=float; float64_t=double; CYT4BFBCHS; CY_USE_PSVP=0; CY_MCU_rev_b; CPU_BOARD_REVA; CY_CORE_CM7_1; BT_ENABLE=1; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\gnss_interface; ..\..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtk_ins.srec
  ILINK.IlinkOutputFile: ins.hex
  ILINK.IlinkConfigDefines: _CORE_cm7_1_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\..\..\linker\linker_directives_tviibh.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include
    ../../include/: cmatrix.h datatype.h define.h earth.h insmech.h insoutmsg.h lcgnssupdate.h lcinsupdate.h lcstruct.h lcsystem.h loosecoupleset.h matrix_wu.h orientation.h positionfilter.h zuptdetect.h rtkcmn.h
  group src
    ../../src/: cmatrix.c earth.c insmech.c insoutmsg.c lcgnssupdate.c lcinsupdate.c lcsystem.c loosecoupleset.c matrix_wu.c orientation.c positionfilter.c zuptdetect.c rtkcmn.c
