<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ins_lib\ins_lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
